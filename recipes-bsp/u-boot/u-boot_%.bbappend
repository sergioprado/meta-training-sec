FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# include any machine specific configuration
include u-boot-${MACHINE}.inc
